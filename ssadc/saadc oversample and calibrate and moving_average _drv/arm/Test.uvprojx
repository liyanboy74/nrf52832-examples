# Keil uVision project Test.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Test
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NRF52 BOARD_PCA10040 DEBUG BSP_DEFINES_ONLY
  c misc: --c99
  c include: ..
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group Source
    ../: main.c uart.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Board Support:bsp 11.0.0-2.alpha, Device:Startup 8.35.0, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_Drivers:nrf_adc 4.0.0-2.alpha, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_saadc 4.0.0-2.alpha, nRF_Drivers:nrf_drv_uart 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_saadc 4.0.0-2.alpha, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Drivers:nrf_uarte 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_fifo 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha
